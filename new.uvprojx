# Keil uVision project new.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: new
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: .\app;.\driver;.\lib;.\service;.\sys;.\lib\CMSIS\startup;.\lib\CMSIS;.\lib\STM32F10x_StdPeriph_Driver\inc;.\lib\STM32F10x_StdPeriph_Driver\src;.\driver\display;.\driver\encoder;.\driver\gpio;.\driver\imu;.\driver\include;.\driver\motor;.\driver\power;.\driver\serial;.\service\math;.\service\pid;.\service\protocol;.\service\scheduler
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group app
    ./app/: main.c
  group driver
    ./driver/display/: oled.c oled_data.c oled.h oled_data.h oled_font.h
    ./driver/encoder/: encoder.c encoder.h
    ./driver/gpio/: led.c key.c key.h led.h
    ./driver/imu/: mpu6050.c mpu6050.h
    ./driver/motor/: motor.c motor_pwm.c tb6612.c motor.h motor_pwm.h tb6612.h
    ./driver/power/: battery.c battery.h
    ./driver/serial/: usart1.c usart2.c usart3.c usart1.h usart2.h usart3.h
    ./driver/include/: display_if.h encoder_if.h imu_if.h motor_if.h power_if.h serial_if.h
  group lib
    ./lib/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
    ./lib/CMSIS/startup/: startup_stm32f10x_md.s
    ./lib/STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
    ./lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group service
    ./service/math/: qmath.c qmath.h
    ./service/pid/: pid.c pid.h
    ./service/protocol/: protocol.c protocol.h
    ./service/scheduler/: timer_scheduler.c timer_scheduler.h
  group sys
    ./sys/: delay.c delay.h delay1.c delay1.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
